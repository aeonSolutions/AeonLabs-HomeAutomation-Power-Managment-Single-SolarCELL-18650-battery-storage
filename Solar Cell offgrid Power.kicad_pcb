# Repository aeonSolutions/AeonLabs-HomeAutomation-Power-Managment-Single-SolarCELL-18650-battery-storage

File README.md:

[PCB-Prototyping-Catalogue](https://github.com/aeonSolutions/PCB-Prototyping-Catalogue)  >>  [Home-Automation](https://github.com/aeonSolutions/PCB-Prototyping-Catalogue/tree/main/Home-Automation)  >>  [Smart Home Solar Power Management](https://github.com/aeonSolutions/PCB-Prototyping-Catalogue/tree/main/Home-Automation/Smart%20Home%20Solar%20Power%20Management)  >>  Single Solar Cell with one 18650 Battery Storage

<br>

<p align="right">
 <a href="https://github-com.translate.goog/aeonSolutions/PCB-Prototyping-Catalogue/tree/main?_x_tr_sl=en&_x_tr_tl=pt&_x_tr_hl=en&_x_tr_pto=wapp">Change Language</a> <br>
Last update: 01-12-2023
</p>

# Single Solar Cell with one 18650 Battery Storage
This is a simple PCB for a direct fit on commercially available 4V to 6V [black solar cell tiles](https://s.click.aliexpress.com/e/_DCSwB9L)  with dimensions up to 124mm wide. This PCB features a single 18650 Battery management system intended for indoor usage. In particular to be installed on the top or downside of transparent glass windows at a home or office. This PCB, when assembled with a blue solar cell tile, can be used to power a low voltage 4.2V indoor illumination network using ultra-low power micro LED strips.  For instance [this one](https://s.click.aliexpress.com/e/_DCKg9xJ) sold on AliExpress.   

When connected in series and installed on several windows and networked, can power off the grid a 4.2V LED illumination on all rooms and compartments at a home or office. During evenings and at night until bedtime. If one intends to use it to power indoors LED illumination during the day is required a High Capacity Power Bank connected to all first tiles of all the series. For instance this [power bank](https://s.click.aliexpress.com/e/_Ddl7nsh) here. 

One important takeway about this prototype project is the ability to be installed on any traditional apartment or home in a big city, requiring  124mm of window glass estate, at the top or at the bottom. And it can connect to existing home automation network or systems. If you prefer can read this project on Autodesk's Intructables.com, [here](https://www.instructables.com/Single-Solar-Cell-With-One-18650-Battery-Storage/).

<p align="center">

</p>

A brief view of specifications:

- 1x 18650 LiPo battery management system
- the PCB can be connected in series to form a length of solar cell tiles packed together (each with its own single BMS. 
- Main ON/OFF switch.
- PCB assembly in series made with a 10-pin header/ socket. For "plug and play" type of installations
- Screw terminal to connect main low power 5V DC line at home/office. 

<br>

**Status**

This PCB electronics is now fully tested and working when connected to a 5V solar tile and is able to charge a 4.2V LiPo battery. Mind you, this is the simplest electronics, with a restriction, one of being only useful for 24H energy storage (LiPo), meaning this electronics is only capable of managing the solar electricity collected during the day, to run during evenings and also at night until the battery is depleted. Therefore is suited for indoor LED illumination and even suited to power small smart electronics/devices. 

<br>

## PCB

<br>

## Compatibility

<p align="center">

</p>

<br>

## What one additionally needs
-  home tools
-  [transparent double sided tape](https://s.click.aliexpress.com/e/_DDJxMmD)
-  [blue solar cell tiles](https://s.click.aliexpress.com/e/_DCnJW0V)
-  [ultra-low power micro LED strips](https://s.click.aliexpress.com/e/_DCKg9xJ) 
-  [ultra-low power  LED Cob strips](https://s.click.aliexpress.com/e/_DnqkC4N)
-  [Nylon Guide for Electric Cable](https://s.click.aliexpress.com/e/_DBc1oVX)
-  [NCR18650B 3.7V 3400 mah 18650 Lithium](https://s.click.aliexpress.com/e/_DCh1sw1)
-  [Low power electrical wire](https://s.click.aliexpress.com/e/_DB1T3eN)
-  [16A Electrical Plug Wall Socket 110~250V Dual USB 2000mA Port](https://s.click.aliexpress.com/e/_DlVz3sh)
-  [Soldering iron](https://s.click.aliexpress.com/e/_DnDN8x3)
-  [Solder](https://s.click.aliexpress.com/e/_DlXtKMN)
- [power bank](https://s.click.aliexpress.com/e/_Ddl7nsh) 

<br />
<br />

## Author

You can get in touch with me on my LinkedIn Profile:

#### Miguel Tomas

You can also follow my GitHub Profile to stay updated about my latest projects: 

<br>

### Be supportive of my dedication and work towards technology education and buy me a cup of coffee
The PCB Desgin Files i provide here for anyone to use are free. If you like this Smart Device or use it, please consider buying me a cup of coffee, a slice of pizza or a book to help me study, eat and think new PCB design files.

<br />

### Make a donation on Paypal
Make a donation on paypal and get a TAX refund*.

<br>

### Support all these open hardware projects and become a patreon  
Liked any of my PCB KiCad Designs? Help and Support my open work to all by becomming a LDAD Patreon.
In return I will give a free PCB design in KiCad to all patreon supporters. To learn more go to patreon.com. Link below.

<br />
<br />

______________________________________________________________________________________________________________________________
### License
Before proceeding to download any of AeonLabs software solutions for open-source development and/or PCB hardware electronics development make sure you are choosing the right license for your project. See [AeonLabs Solutions for Open Hardware & Source Development](https://github.com/aeonSolutions/PCB-Prototyping-Catalogue/wiki/AeonLabs-Solutions-for-Open-Hardware-&-Source-Development) for more information.

## KiCad design Solar Cell offgrid Power.kicad_pcb

Parts:
BAT_POS1: BAT+; TestPoint_Pad_3.0x3.0mm
BK1, BK2, BK3, BK4, BK5, BK6, BK7, BK8: Copper Track Breaker; Copper Track Breaker 2 points
BT1: BK-18650-PC2; batery holder BAT_BK-18650-PC2; PARTREV F
D1: 1N5712; D_SOD-123
J1: Conn_01x10_Socket; PinSocket_1x10_P2.54mm_Horizontal
J2: Conn_01x10_Pin; PinHeader_1x10_P2.54mm_Horizontal
J3: Screw_Terminal_01x02; TerminalBlock_Phoenix_MPT-0,5-2-2.54_1x02_P2.54mm_Horizontal
J4: Conn_02x03_Counter_Clockwise; Toggle Switch 2 pos PCB MSS-22D18G2 2P2T
Q1: S8550; SOT-23-3
R1: 5K6; R_1210_3225Metric
SC_POS1: SC+; TestPoint_Pad_3.0x3.0mm
TPBAT_NEG1: BAT-; TestPoint_Pad_3.0x3.0mm
TPSC_NEG1: SC-; TestPoint_Pad_3.0x3.0mm

Connections:
BAT+: BAT_POS1.1, BK1.1, BK2.1, BK3.1, BK4.1, BK5.1, BK6.1, BK7.1, BK8.1, BT1.+, D1.1 (K), Q1.2 (E)
Conn_track_1: BK4.2, J1.1, J2.1
Conn_track_2: BK5.2, J1.2, J2.2
Conn_track_3: BK6.2, J1.3, J2.3
Conn_track_4: BK7.2, J1.4, J2.4
Conn_track_7: BK8.2, J1.7, J2.7
Conn_track_8: BK1.2, J1.8, J2.8
Conn_track_9: BK2.2, J1.9, J2.9
Conn_track_10: BK3.2, J1.10, J2.10
GND: BT1.-, J1.6, J2.6, J3.1, TPBAT_NEG1.1, TPSC_NEG1.1
unnamed: D1.2 (A), R1.1, SC_POS1.1
unnamed: J4.1, J4.6
unnamed: Q1.1 (B), R1.2
PWR: J1.5, J2.5, J4.2, J4.5, Q1.3 (C)
PWR_HOME: J3.2, J4.3, J4.4

Board: 2 copper layers, 124.5 x 68.1 mm, 20 parts (0 on the bottom side), 15 nets.
